
LICENSE = "GPLv2"
FILESEXTRAPATHS_append := "${THISDIR}/files:"


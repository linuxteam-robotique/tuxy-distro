
hostname = "${DISTRO}"


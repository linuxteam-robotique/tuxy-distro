
SRC = "${EXTERNAL_TOOLCHAIN}/arm-linux-gnueabihf/libc/usr/bin"

